# Keil uVision project atk_f103.uvprojx, settings and files
target Template (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32F103xE,USE_HAL_DRIVER
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers;..\..\User;..\..\Drivers\BSP\led
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/usart/: usart.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
  group Drivers/STM32F103_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group User
    ../../User/: stm32f1xx_it.c main.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/beep/: beep.c
    ../../Drivers/BSP/key/: key.c
    ../../Drivers/BSP/exti/: exti.c
    ../../Drivers/BSP/iwdg/: iwdg.c
    ../../Drivers/BSP/wwdg/: wwdg.c
    ../../Drivers/BSP/btim/: btim.c
